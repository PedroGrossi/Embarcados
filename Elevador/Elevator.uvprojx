# Keil uVision project Elevator.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Elevator +hex
  AfterMake: fromelf.exe --bin Objects\Elevator.axf --output Objects\Elevator.bin
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  c include: ..\TivaWare_C_Series-2.2.0.295
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --entry Reset_Handler
  group Source
    ./: main.c startup_rvmdk.S
  group Documentation
    ./: readme.txt
  group Libraries
    ../TivaWare_C_Series-2.2.0.295/driverlib/rvmdk/: driverlib.lib
software components: RTOS:Config 10.5.1, RTOS:Core 10.5.1, RTOS:Heap 10.5.1, RTOS:Timers 10.5.1, CMSIS:CORE 6.1.0
